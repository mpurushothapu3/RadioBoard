# Repository mpurushothapu3/RadioBoard

File README.md:

# RadioBoard
Custom radio device used to communicate with robots, includes port for display via SPI

## EAGLE design Radii.brd

Parts:
C1, C2, C3, C6, C9, C10, C11, C15, C16, C17, C18, C19, C20: 0.1uF; 0603
C4: 1.0uF; 0603
C5: 10uF; 0603
C7, C8: 22uF; 1210
C12: 10nF; 0603
C13, C14: 33pF; 0603
D1, D2: GREEN; CHIP-LED0603
J1: 10118193-0001LF; FCI_10118193-0001LF
J2, J3, J4, J5, J6: BUTTON; 1X02
J7: S2B-PH-SM4-TB(LF)(SN); JST_S2B-PH-SM4-TB(LF)(SN)
JP1: PINHD-1X7; 1X07
JP2: PINHD-1X1; 1X01
Q1: PMOS; SOT-23-3
R1, R2: 22Ω; 0603-RES
R3, R4: 0603
R5, R6, R8, R10, R11, R13, R15, R17: 10K; 0603-RES
R7, R9, R12, R14, R16: 1K; 0603-RES
S1: KMR2
U1: RFM69HCW_SMT; RFMHCW_SMT
U2: ATMEGA32U4-AU; 44-TQFP(10X10)
U3: AP63203WU-7; TSOT-23-6
U4: 3.9uH; 1255AY-3R9N=P3
Y1: 8.000 MHz; XTAL_ECS-80-20-5PX-TR

Connections:
3.3V: C1.1, C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, C11.1, D2.A, J2.1, J3.1, J4.1, J5.1, J6.1, JP1.1, R10.1, R11.2, R17.2, U1.5P (VDD), U2.6 (UCAP), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC), U2.44 (AVCC), U3.1 (FB), U4.2
9V: C5.1, D1.A, Q1.2 (S), U3.2 (EN), U3.3 (VIN)
BUTTON1: C17.1, R7.1, U2.20 (PD2(RXD1/INT2))
BUTTON2: C16.1, R12.1, U2.21 (PD3(TXD1/INT3))
BUTTON3: C19.1, R14.1, U2.25 (PD4(ICP1/ADC8))
BUTTON4: C18.1, R9.1, U2.22 (PD5(XCK1/!CTS!))
BUTTON5: C20.1, R16.1, U2.27 (PD7(T0/OC4D/ADC10))
CS: JP1.5, R17.1, U2.30 (PB6(PCINT6/OC1B/OC4B/ADC))
DC_SELECT: JP1.7, U2.28 (PB4(PCINT4/ADC11))
DIFF1_N: R1.2, U2.3 (D-)
DIFF1_P: R2.2, U2.4 (D+)
DIFF_N: J1.2 (D-), R1.1
DIFF_P: J1.3 (D+), R2.1
DISP_RESET: JP1.6, U2.29 (PB5(PCINT5/OC1A/OC4B/ADC))
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, J1.5 (GND), J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J1.S5 (SHIELD), J1.S6 (SHIELD), J7.2, J7.S1 (SHIELD), J7.S2 (SHIELD), JP1.2, Q1.1 (G), R3.2, R4.2, R5.1, R6.1, R8.1, R13.1, R15.1, S1.2.1 (2), S1.2.2 (2), U1.2P (GND), U1.9P (GND), U1.16P (GND), U2.5 (UGND), U2.15 (GND), U2.23 (GND), U2.35 (GND), U2.43 (GND), U3.4 (GND)
INT: U1.6P (DIO0), U2.36 (PF7(ADC7/TDI))
MISO: U1.10P (MISO), U2.11 (PB3(PDO/PCINT3/MISO))
MOSI: JP1.4, U1.11P (MOSI), U2.10 (PB2(PDI/PCINT2/MOSI))
unnamed: C6.2, U3.5 (SW), U4.1
unnamed: C6.1, U3.6 (BST)
unnamed: JP2.1, U1.1P (ANT)
unnamed: J3.2, R6.2, R7.2
unnamed: C13.1, U2.16 (XTAL2), Y1.2
unnamed: C12.1, U2.42 (AREF)
unnamed: C14.1, U2.17 (XTAL1), Y1.1
unnamed: D1.C (K), R3.1
unnamed: D2.C (K), R4.1
unnamed: J2.2, R5.2, R12.2
unnamed: J4.2, R8.2, R9.2
unnamed: J5.2, R13.2, R14.2
unnamed: J6.2, R15.2, R16.2
unnamed: C15.1, R10.2, S1.1.1 (1), S1.1.2 (1), U2.13 (!RESET)
RADIO_RESET: U1.14P (RESET), U2.37 (PF6(ADC6/TDO))
SCK: JP1.3, U1.12P (SCK), U2.9 (PB1(PCINT1/SCLK))
SS: R11.1, U1.13P (NSS), U2.38 (PF5(ADC5/TMS))
VCC: J7.1, Q1.3 (D)
VUSB: J1.1 (VUSB), U2.7 (VBUS)

Notes on the sheet:
Power
MCU Pinout
Radio Module
LCD Display
Radio Debugging Device for Sumo Bot
RoboWrestling
USB Connector
Buttons

Board: 2 copper layers, 42.6 x 44.9 mm, 57 parts (2 on the bottom side), 37 nets.

Other parts of the board:
U$1: ROBOBUZZ_0.8X
U$2: ROBOJACKETS

## Commit log

2020-12-22 Import design and image files

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
